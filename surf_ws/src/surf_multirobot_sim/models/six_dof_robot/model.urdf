Commit message: removed drone nose

File: surf_ws/src/surf_multirobot_sim/models/six_dof_robot/model.urdf (robot description, URDF)
Before this commit: robot surf_six_dof_robot, 3 links, 2 joints
Links:
- removed link nose
Joints:
- removed joint nose_visual_joint
